FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SERIAL_CONSOLES += " 115200;ttyGS0 115200;ttyPS0"
